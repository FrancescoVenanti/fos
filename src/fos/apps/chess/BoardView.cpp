#include "BoardView.h"

#include "fos/ui/Components.h"
#include "fos/ui/Fonts.h"
#include "fos/ui/Theme.h"
#include "fos/ui/generated/ChessPieceData.h"

namespace fos::chess {

using namespace ui;

namespace {

ui::Rect squareRect(const ui::Rect& r, const bool flipped, const int sq) {
  const int file = fileOf(sq);
  const int rank = rankOf(sq);
  const int col = flipped ? 7 - file : file;
  const int row = flipped ? rank : 7 - rank;
  return {r.x + col * SQUARE, r.y + row * SQUARE, SQUARE, SQUARE};
}

bool lightSquare(const int sq) { return (fileOf(sq) + rankOf(sq)) % 2 == 1; }

}  // namespace

void squareName(const int sq, char* out) {
  out[0] = static_cast<char>('a' + fileOf(sq));
  out[1] = static_cast<char>('1' + rankOf(sq));
  out[2] = '\0';
}

int squareAt(const ui::Rect& r, const bool flipped, const int x, const int y) {
  if (!r.contains(x, y)) return -1;
  const int col = (x - r.x) / SQUARE;
  const int row = (y - r.y) / SQUARE;
  const int file = flipped ? 7 - col : col;
  const int rank = flipped ? row : 7 - row;
  return rank * 8 + file;
}

void drawPiece(Canvas& c, const int x, const int y, const int type, const bool white, const int size) {
  if (type < PAWN || type > KING) return;
  const int color = white ? 0 : 1;
  const uint8_t* solid = size == 32 ? pieces::SOLID_32[color][type - 1] : pieces::SOLID_48[color][type - 1];
  const uint8_t* ink = size == 32 ? pieces::INK_32[color][type - 1] : pieces::INK_48[color][type - 1];
  const int px = size == 32 ? 32 : 48;
  c.bits(solid, x, y, px, px, Tone::White);
  c.bits(ink, x, y, px, px, Tone::Black);
}

void drawBoard(Canvas& c, const ui::Rect& r, const Position& pos, const BoardStyle& style, const uint16_t action) {
  c.frame(r.inset(-theme::BORDER), theme::BORDER, Tone::Black);
  for (int sq = 0; sq < 64; ++sq) {
    const ui::Rect s = squareRect(r, style.flipped, sq);
    const bool light = lightSquare(sq);
    Tone bg = light ? Tone::White : Tone::Light;
    if (sq == style.checkSquare) bg = Tone::Dark;
    if (sq == style.marked) bg = Tone::Black;
    c.fill(s, bg);

    // Last move: corner marks on both squares.
    if (sq == style.lastFrom || sq == style.lastTo) {
      constexpr int L = 12;
      constexpr int T = 4;
      c.fill({s.x, s.y, L, T}, Tone::Black);
      c.fill({s.x, s.y, T, L}, Tone::Black);
      c.fill({s.right() - L, s.y, L, T}, Tone::Black);
      c.fill({s.right() - T, s.y, T, L}, Tone::Black);
      c.fill({s.x, s.bottom() - T, L, T}, Tone::Black);
      c.fill({s.x, s.bottom() - L, T, L}, Tone::Black);
      c.fill({s.right() - L, s.bottom() - T, L, T}, Tone::Black);
      c.fill({s.right() - T, s.bottom() - L, T, L}, Tone::Black);
    }

    const int8_t v = pos.sq[sq];
    if (style.showPieces && v) drawPiece(c, s.x + (SQUARE - 48) / 2, s.y + (SQUARE - 48) / 2, pieceType(v), isWhite(v));

    if (style.targets & (1ULL << sq)) {
      if (v) {
        // Capture target: a ring of corner triangles.
        constexpr int K = 14;
        c.triangle(s.x, s.y, s.x + K, s.y, s.x, s.y + K, Tone::Black);
        c.triangle(s.right() - 1, s.y, s.right() - 1 - K, s.y, s.right() - 1, s.y + K, Tone::Black);
        c.triangle(s.x, s.bottom() - 1, s.x + K, s.bottom() - 1, s.x, s.bottom() - 1 - K, Tone::Black);
        c.triangle(s.right() - 1, s.bottom() - 1, s.right() - 1 - K, s.bottom() - 1, s.right() - 1, s.bottom() - 1 - K,
                   Tone::Black);
      } else {
        const int d = 16;
        c.fill({s.x + (SQUARE - d) / 2, s.y + (SQUARE - d) / 2, d, d}, Tone::Black);
      }
    }
    if (sq == style.selected) c.frame(s, 5, Tone::Black);
    if (action) c.hit(s, action, static_cast<int16_t>(sq));
  }
  if (style.coordinates) {
    // Outside the frame: ranks in the left margin, files below.
    const int lh = c.lineHeight(font::SMALL);
    for (int i = 0; i < 8; ++i) {
      const char rank[2] = {static_cast<char>('1' + (style.flipped ? i : 7 - i)), ''};
      const char file[2] = {static_cast<char>('a' + (style.flipped ? 7 - i : i)), ''};
      c.textIn({r.x - theme::BORDER - 20, r.y + i * SQUARE, 16, SQUARE}, font::SMALL, rank, Tone::Dark, Align::Center,
               true);
      c.textIn({r.x + i * SQUARE, r.bottom() + theme::BORDER, SQUARE, lh}, font::SMALL, file, Tone::Dark, Align::Center,
               true);
    }
  }
}

}  // namespace fos::chess
